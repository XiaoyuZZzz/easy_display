# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Users\user\Desktop\Stupid_child\Stupid-child\demo\stm32_f4\example_pro\project\MDK(V5)\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\app;..\..\board;..\..\bsp;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\module;..\..\bsp\uart;..\..\..\..\..\driver_pack;..\..\..\..\..\driver_pack\log\src;..\..\..\..\..\driver_pack\log\inc;..\..\..\..\..\driver_pack\RTT;..\..\..\..\..\driver_pack\RTT\Config;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Include;..\..\..\..\..\driver_pack\tool\src;..\..\..\..\..\driver_pack\tool\inc;..\..\..\..\..\driver_pack\lcd\src;..\..\..\..\..\driver_pack\lcd\inc;..\..\..\..\..\driver_pack\command\src;..\..\..\..\..\driver_pack\command\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\driver_pack\sc_make.sct
  group APP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../app/: main.c
    ../../module/: stm32f4xx_it.c
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group BSP
    ../../bsp/uart/: bsp_uart.c
    ../../board/: mcu_flash.c time_tick.c mcu_spi.c
  group Board
    ../../board/: board.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group debug
    ../../../../../driver_pack/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group DOC
    ../../: README.md
  group Middle
    ../../../../../driver_pack/log/src/: sc_log.c
    ../../../../../driver_pack/lcd/src/: lcd_driver.c
  group tool
    ../../../../../driver_pack/tool/src/: cbtimer.c c_unit.c
  group command
    ../../../../../driver_pack/command/src/: command.c
  group Middle/lcd_middle
    ../../../../../driver_pack/lcd/src/: epd.c st7789.c
  group UI
    ../../../../../driver_pack/lcd/src/: lcd_ui.c
